# IAR project Thermostat.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\library\inc; library\CoreSupport; user_inc; ..\Thermostat
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Thermostat.hex
  ILINK.IlinkOutputFile: Thermostat.out
  ILINK.IlinkIcfFile: stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../library/CoreSupport/: core_cm3.c
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group StdPeriph_Driver
    ../library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    user_main/: bsp.c bsp_beep.c bsp_disp.c bsp_rtc.c bsp_usart.c COMUSE.C eeprom.c GloblDef.c I2C.c init.c main.c menu_key.c out.c sci1.c sci3.c stm32f10x_it.c Temp_Hum.c
